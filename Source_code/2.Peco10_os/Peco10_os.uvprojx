# Keil uVision project Peco10_os.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G031F8Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Peco10_os
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include
  asm include: .\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Inc
    ./Include/: attributes.h Keypad.h Lcd_character.h Lcd_segment.h Main_App.h Rs485.h Standard.h swtimer.h
  group Src
    ./Source/: Keypad.c Lcd_character.c Lcd_segment.c Main_App.c Rs485.c Standard.c swtimer.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G031F8Px/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G031F8Px/STCubeGenerated/Inc/: stm32g0xx_it.h
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:SPI 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 1.4.0
